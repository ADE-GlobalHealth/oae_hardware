.title KiCad schematic
.save all
J202 __J202
J201 __J201
J205 __J205
J204 __J204
J203 __J203
J206 __J206
F301 __F301
C304 +3V3 GND 1u
U301 __U301
TP301 __TP301
C301 Net-_U301-VI_ GND 10u
C302 +3V3 GND 22u
C303 +3V3 GND 10u
TP304 __TP304
TP303 __TP303
TP302 __TP302
U501 __U501
TP503 __TP503
R505 Net-_D503-K_ GND 200
TP501 __TP501
R503 Net-_D501-K_ GND 200
D501 __D501
R504 Net-_D502-K_ GND 200
TP502 __TP502
D502 __D502
D503 __D503
C502 /Microcontroller/XTAL2 GND 30p
C501 /Microcontroller/XTAL1 GND 30p
R502 Net-_U501-PC11_ USART1_RX 1k
R501 Net-_U501-PC10_ USART1_TX 1k
Y501 __Y501
C503 nRST GND 1u
SW501 __SW501
SW502 __SW502
C401 +3V3 GND 10u
C404 +3V3 GND 1u
C407 +3V3 GND 4.7u
C411 +3V3 GND 10n
C410 +3V3 GND 100n
C409 +3V3 GND 1u
C406 +3V3 GND 100n
C408 +3V3 GND 1u
C402 +3V3 GND 4.7u
C405 +3V3 GND 100n
C403 +3V3 GND 4.7u
C603 +3V3 GND 10u
C602 +3V3 GND 1u
C601 +3V3 GND 100n
U601 __U601
RN601 __RN601
TP601 __TP601
C604 Net-_C604-Pad1_ SPEAKER_A 47u
R601 SPEAKER_A_SIG Net-_U601B--_ 10k
TP603 __TP603
R604 Net-_U601A--_ Net-_C605-Pad1_ 499
R603 Net-_U601B--_ Net-_C604-Pad1_ 499
R602 SPEAKER_B_SIG Net-_U601A--_ 10k
TP602 __TP602
C605 Net-_C605-Pad1_ SPEAKER_B 47u
R709 Net-_C709-Pad2_ Net-_C710-Pad1_ 2k
C711 Net-_U702B--_ /Microphone_Filters_and_Amp/External_ADC 10n
TP703 __TP703
R712 Net-_U702B--_ /Microphone_Filters_and_Amp/External_ADC 2k
U702 __U702
C710 Net-_C710-Pad1_ Net-_U702B--_ 100n
C707 +3V3 GND 10u
C705 +3V3 GND 1u
C702 +3V3 GND 100n
RN701 __RN701
R701 Net-_RN701-R1.2_ Net-_U701--_ 10k
C703 MIC_IN Net-_RN701-R1.2_ 47u
R708 Net-_U702A--_ Net-_C709-Pad2_ 2k
C709 Net-_U702A--_ Net-_C709-Pad2_ 10n
C708 Net-_C708-Pad1_ Net-_U702A--_ 100n
R705 Net-_R702-Pad2_ Net-_C708-Pad1_ 2k
U701 __U701
R702 Net-_U701--_ Net-_R702-Pad2_ 150k
C713 +3V3 GND 1u
C712 +3V3 GND 0.1u
.end
